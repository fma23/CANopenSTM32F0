# Keil uVision project CAN.uvproj, settings and files
target Simulator (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CanDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F072, __USE_LCD,USE_STDPERIPH_DRIVER,STM32F072xB
  c include: .\Application;..\CANopenSTM32F0;.\CANopen;.\STMlib;.\Application\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f072.s
  group Application
    ./Application/src/: isr.c timer.c application.c main.c led.c
  group CANopen
    ./CANopen/: CANopen.c CO_common.c co_driver.c CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_OD.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c crc16-ccitt.c
  group STMLib
    ./STMlib/: stm32f0xx_can.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_iwdg.c stm32f0xx_tim.c system_stm32f0xx.c
target CANBus (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: CanDemo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F072,USE_STDPERIPH_DRIVER,STM32F072xB
  c include: ..\CANopenSTM32F0;.\STMlib;.\CANopen;.\Application\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
